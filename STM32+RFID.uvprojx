# Keil uVision project STM32+RFID.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32+RFID
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: C:\Users\Legion\Desktop\STM32+RFID\
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group uart_debug
    ./: uart_debug.c uart_debug.h
  group Src
    ./: main.c
  group rc522
    ./: rc522.c rc522.h
  group delay
    ./: delay.c delay.h
  group pwm
    ./: pwm.c pwm.h
  group sd card
    ./: diskio.h fatfs.h fatfs_sd.h ff.h ffconf.h integer.h user_diskio.h fatfs.c ff.c user_diskio.c diskio.c fatfs_sd.c ff_gen_drv.c
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
